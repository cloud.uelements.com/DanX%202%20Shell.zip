Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DanX 2 Shell.IFC
Time: 2014-05-20T13:29:22
Written by: SwIFC
Made in: SolidWorks 2014

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 00000862 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 012103 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 028278 (12)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 041656(Monteret) (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 062192 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066631(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066632(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066634(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066635(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066637(Default) (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066638(Default) (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066640(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066641(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066643(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066644(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066659(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066660(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066661(Default) (12)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066662(Default) (12)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066663(Default) (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066807(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 066808(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067291(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067292(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067293(Default) (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067306(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067307(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067308(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067309(Default) (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067310(Default) (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067312(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067316
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067317(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067318(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067896(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 067896_old(Default) (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 068015(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 068037
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 068158(Default) (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 068160(Default) (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 068519(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 068607
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 12128 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 265076-311 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 26507601_26507601 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 26507802_26507802 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 26507803 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 26507805 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 26507808 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 26507824 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 297017 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 457630(Default) (8)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 524190 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 524192 (7)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 524750 (7)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 527030
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 527034(Default)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 527560 (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 541831 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 541832 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: 541839 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Hængsel del 1 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Hængsel del 2 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Hængsel nagle (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported1 (9)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported10
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported2 (9)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported3 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported4 (4)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported5 (3)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported6 (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported7 (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported8 (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Imported9 (2)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Låge-dækplade indre DanX 1-2(066648)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Låge-dækplade indre DanX 1-2(066651)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Låge-dækplade indre DanX 1-2(066654)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Låge-dækplade indre DanX 1-2(066656)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Låge-dækplade ydre DanX 1-2(066647)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Låge-dækplade ydre DanX 1-2(066650)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Låge-dækplade ydre DanX 1-2(066653)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: Låge-dækplade ydre DanX 1-2(066657)
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: RJ 45_C-0555052-01-3
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers

# IfcBuildingElementProxy: isolering eludtag
In: Default Storey
PSet_Type_Identity_Data - OmniClass Number: 23.75.65.11.17; OmniClass Title: Heating Optimizers/Economizers
